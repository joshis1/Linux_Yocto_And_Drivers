LINUX_VERSION = "4.19"
KUSH_RELEASE_VERSION = "v2020.1"
KBRANCH ?= "warrior"
SRCREV ?= "3305515e9fb4e8fd70b70522e4d849f167d34ed1"

include linux-xlnx.inc

